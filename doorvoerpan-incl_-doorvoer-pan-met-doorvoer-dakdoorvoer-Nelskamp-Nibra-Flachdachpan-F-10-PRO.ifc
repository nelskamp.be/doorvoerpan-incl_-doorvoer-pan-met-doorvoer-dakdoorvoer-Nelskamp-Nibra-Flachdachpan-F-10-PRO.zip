Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: afc54a2e-9cb1-4013-89c1-e85003a62c54.ifc
Time: 2025-02-03T14:21:19
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcFlowTerminal, doorvoerpan incl. doorvoer pan met doorvoer dakdoorvoer Nelskamp - Nibra Flachdachpan F-10 PRO
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAGNvvNsCAAAA7NICAAVc6AAAj6cAADxtAQCC1gIA0NYCAAEAAQUBAQAAAAEAAACZ1gIABVaQAACGUgAAq0sAAA3WAgB70gIAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAGNvvNsCAAAA7NICAAVc6AAAj6cAADxtAQCC1gIA0NYCAAEAAQUBAQAAAAEAAACZ1gIABVaQAACGUgAAq0sAAA3WAgB70gIAAAA); merk: Nelskamp; kleur: natuurrood (601); kenmerkende grondstof: terracotta; serie: Nibra Flachdachpan F-10 PRO; tussenpan: keramische tussenpan Nelskamp - Nibra Flachdachpan F-10 PRO natuurrood (601)
